# Repository comakingspace/FlipDotDisplay

File README.md:

# FlipDotDisplay
3 old flip dot displays which need some work to get up and running.

They were bought at the Makerfaire Hannover 2016.

Hardware design is made in KiCAD 4.

## Function

A dot on the display is switched by magnetising an inductor, which causes the colored dot (with a small magnet embedded) to change the orientation. Because the core of the inductor stays magnetized the state of the dot is stable even without being powered.

The inductors of the pixels are hooked up in an array with 24x16. Each column is connected to a single pin of the connector and each row has two inputs; one for positive voltage and one for negative (see FlipDotSchematic). By applying a voltage to a row and a column the corresponding pixel is flipped depending on the current flow direction. The original driver probably used two different power rails and sets of transistors to change the direction of the dot. 

The new driver will use a half-bridge configuration on each input to select the current flow direction. 

## ICs

* Half-bridge driver ICs: **L293D**
* Shift registers for output : **SN74HC595**
* Controller: **Atmega328p** (communicates via serial with the ESP8266)
* Interface for network: ESP8266 (Wemos D1 mini)

## Features

* [Adafruit GFX library](https://github.com/adafruit/Adafruit-GFX-Library) implementation
* MQTT string scroll text

## ToDo

* Pull tweets and display them (direct Hex code or text)
* Binary via MQTT
* more ?

## KiCad design Schematics_H-Bridge/Flipdot_H-Bridge.kicad_pcb

Parts:
C1: 100nF; C_Disc_D4.7mm_W2.5mm_P5.00mm
C2: 10uF; CP_Radial_D6.3mm_P2.50mm
D1: Led_Green; LED_D3.0mm
D2: Led_Yellow; LED_D3.0mm
D3: Led_Red; LED_D3.0mm
J1: Barrel_Jack; BARREL_JACK
P1: CONN_02X13; Pin_Header_Straight_2x13_Pitch2.54mm
P2, P3: CONN_02X08; Pin_Header_Straight_2x08_Pitch2.54mm
R1: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R2: 2k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R3, R4, R5: 1.5K; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
U1, U2, U7, U8, U13: 74HC595; DIP-16_W7.62mm_Socket_LongPads
U3, U4, U5, U6, U9, U10, U11, U12, U14, U15, U16, U17, U18, U19, U21, U22, U23, U24, U25, U26: L293D; DIP-16_W7.62mm_Socket_LongPads
U20: ESP8266_D1_Mini

Connections:
+5V: C1.1, U1.10 (SRCLR), U1.16 (VCC), U2.10 (SRCLR), U2.16 (VCC), U3.16 (Vcc1), U4.16 (Vcc1), U5.16 (Vcc1), U6.16 (Vcc1), U7.10 (SRCLR), U7.16 (VCC), U8.10 (SRCLR), U8.16 (VCC), U9.16 (Vcc1), U10.16 (Vcc1), U11.16 (Vcc1), U12.16 (Vcc1), U13.10 (SRCLR), U13.16 (VCC), U14.16 (Vcc1), U15.16 (Vcc1), U16.16 (Vcc1), U17.16 (Vcc1), U18.16 (Vcc1), U19.16 (Vcc1), U20.9 (5V), U21.16 (Vcc1), U22.16 (Vcc1), U23.16 (Vcc1), U24.16 (Vcc1), U25.16 (Vcc1), U26.16 (Vcc1); also elsewhere on the board
+12V: C2.1, J1.1, U3.8 (Vcc2), U4.8 (Vcc2), U5.8 (Vcc2), U6.8 (Vcc2), U9.8 (Vcc2), U10.8 (Vcc2), U11.8 (Vcc2), U12.8 (Vcc2), U14.8 (Vcc2), U15.8 (Vcc2), U16.8 (Vcc2), U17.8 (Vcc2), U18.8 (Vcc2), U19.8 (Vcc2), U21.8 (Vcc2), U22.8 (Vcc2), U23.8 (Vcc2), U24.8 (Vcc2), U25.8 (Vcc2), U26.8 (Vcc2); also elsewhere on the board
/+Y1: P2.1, U5.3 (1Y)
/+Y2: P2.3, U5.14 (4Y)
/+Y3: P2.5, U11.3 (1Y)
/+Y4: P2.7, U11.14 (4Y)
/+Y5: P2.9, U16.3 (1Y)
/+Y6: P2.11, U16.14 (4Y)
/+Y7: P2.13, U21.3 (1Y)
/+Y8: P2.15, U21.14 (4Y)
/+Y9: P3.1, U6.3 (1Y)
/+Y10: P3.3, U6.14 (4Y)
/+Y11: P3.5, U12.3 (1Y)
/+Y12: P3.7, U12.14 (4Y)
/+Y13: P3.9, U17.3 (1Y)
/+Y14: P3.11, U17.14 (4Y)
/+Y15: P3.13, U22.3 (1Y)
/+Y16: P3.15, U22.14 (4Y)
/-Y1: P2.2, U5.6 (2Y)
/-Y2: P2.4, U5.11 (3Y)
/-Y3: P2.6, U11.6 (2Y)
/-Y4: P2.8, U11.11 (3Y)
/-Y5: P2.10, U16.6 (2Y)
/-Y6: P2.12, U16.11 (3Y)
/-Y7: P2.14, U21.6 (2Y)
/-Y8: P2.16, U21.11 (3Y)
/-Y9: P3.2, U6.6 (2Y)
/-Y10: P3.4, U6.11 (3Y)
/-Y11: P3.6, U12.6 (2Y)
/-Y12: P3.8, U12.11 (3Y)
/-Y13: P3.10, U17.6 (2Y)
/-Y14: P3.12, U17.11 (3Y)
/-Y15: P3.14, U22.6 (2Y)
/-Y16: P3.16, U22.11 (3Y)
/DATA_X: U3.2 (1A), U3.7 (2A), U3.10 (3A), U3.15 (4A), U4.2 (1A), U4.7 (2A), U4.10 (3A), U4.15 (4A), U9.2 (1A), U9.7 (2A), U9.10 (3A), U9.15 (4A), U10.2 (1A), U10.7 (2A), U10.10 (3A), U10.15 (4A), U14.2 (1A), U14.7 (2A), U14.10 (3A), U14.15 (4A), U15.2 (1A), U15.7 (2A), U15.10 (3A), U15.15 (4A), U18.2 (1A), U18.7 (2A), U18.10 (3A), U18.15 (4A), U19.2 (1A), U19.7 (2A), U19.10 (3A), U19.15 (4A), U23.2 (1A), U23.7 (2A), U23.10 (3A), U23.15 (4A), U24.2 (1A), U24.7 (2A), U24.10 (3A), U24.15 (4A), U25.2 (1A), U25.7 (2A), U25.10 (3A), U25.15 (4A), U26.2 (1A), U26.7 (2A), U26.10 (3A), U26.15 (4A); also elsewhere on the board
/DATA_Y: U5.2 (1A), U5.7 (2A), U5.10 (3A), U5.15 (4A), U6.2 (1A), U6.7 (2A), U6.10 (3A), U6.15 (4A), U11.2 (1A), U11.7 (2A), U11.10 (3A), U11.15 (4A), U12.2 (1A), U12.7 (2A), U12.10 (3A), U12.15 (4A), U16.2 (1A), U16.7 (2A), U16.10 (3A), U16.15 (4A), U17.2 (1A), U17.7 (2A), U17.10 (3A), U17.15 (4A), U21.2 (1A), U21.7 (2A), U21.10 (3A), U21.15 (4A), U22.2 (1A), U22.7 (2A), U22.10 (3A), U22.15 (4A); also elsewhere on the board
/Driver/ATM_RX: U20.16 (TX); also elsewhere on the board
/Driver/ATM_TX: R1.2, R2.1; also elsewhere on the board
/EN_X1: U1.15 (QA), U3.1 (1,2EN)
/EN_X2: U1.1 (QB), U3.9 (3,4EN)
/EN_X3: U1.2 (QC), U9.1 (1,2EN)
/EN_X4: U1.3 (QD), U9.9 (3,4EN)
/EN_X5: U1.4 (QE), U14.1 (1,2EN)
/EN_X6: U1.5 (QF), U14.9 (3,4EN)
/EN_X7: U1.6 (QG), U18.1 (1,2EN)
/EN_X8: U1.7 (QH), U18.9 (3,4EN)
/EN_X9: U7.15 (QA), U23.1 (1,2EN)
/EN_X10: U7.1 (QB), U23.9 (3,4EN)
/EN_X11: U7.2 (QC), U25.1 (1,2EN)
/EN_X12: U7.3 (QD), U25.9 (3,4EN)
/EN_X13: U4.1 (1,2EN), U7.4 (QE)
/EN_X14: U4.9 (3,4EN), U7.5 (QF)
/EN_X15: U7.6 (QG), U10.1 (1,2EN)
/EN_X16: U7.7 (QH), U10.9 (3,4EN)
/EN_X17: U13.15 (QA), U15.1 (1,2EN)
/EN_X18: U13.1 (QB), U15.9 (3,4EN)
/EN_X19: U13.2 (QC), U19.1 (1,2EN)
/EN_X20: U13.3 (QD), U19.9 (3,4EN)
/EN_X21: U13.4 (QE), U24.1 (1,2EN)
/EN_X22: U13.5 (QF), U24.9 (3,4EN)
/EN_X23: U13.6 (QG), U26.1 (1,2EN)
/EN_X24: U13.7 (QH), U26.9 (3,4EN)
/EN_Y1: U2.15 (QA), U5.1 (1,2EN)
/EN_Y2: U2.1 (QB), U5.9 (3,4EN)
/EN_Y3: U2.2 (QC), U11.1 (1,2EN)
/EN_Y4: U2.3 (QD), U11.9 (3,4EN)
/EN_Y5: U2.4 (QE), U16.1 (1,2EN)
/EN_Y6: U2.5 (QF), U16.9 (3,4EN)
/EN_Y7: U2.6 (QG), U21.1 (1,2EN)
/EN_Y8: U2.7 (QH), U21.9 (3,4EN)
/EN_Y9: U6.1 (1,2EN), U8.15 (QA)
/EN_Y10: U6.9 (3,4EN), U8.1 (QB)
/EN_Y11: U8.2 (QC), U12.1 (1,2EN)
/EN_Y12: U8.3 (QD), U12.9 (3,4EN)
/EN_Y13: U8.4 (QE), U17.1 (1,2EN)
/EN_Y14: U8.5 (QF), U17.9 (3,4EN)
/EN_Y15: U8.6 (QG), U22.1 (1,2EN)
/EN_Y16: U8.7 (QH), U22.9 (3,4EN)
/OE: U1.13 (G), U2.13 (G), U7.13 (G), U8.13 (G), U13.13 (G); also elsewhere on the board
/X1: P1.1, U3.3 (1Y)
/X2: P1.2, U3.14 (4Y)
/X3: P1.3, U9.3 (1Y)
/X4: P1.4, U9.14 (4Y)
/X5: P1.5, U14.3 (1Y)
/X6: P1.6, U14.14 (4Y)
/X7: P1.7, U18.3 (1Y)
/X8: P1.8, U18.14 (4Y)
/X9: P1.9, U23.3 (1Y)
/X10: P1.10, U23.14 (4Y)
/X11: P1.11, U25.3 (1Y)
/X12: P1.12, U25.14 (4Y)
/X13: P1.13, U4.3 (1Y)
/X14: P1.14, U4.14 (4Y)
/X15: P1.15, U10.3 (1Y)
/X16: P1.16, U10.14 (4Y)
/X17: P1.17, U15.3 (1Y)
/X18: P1.18, U15.14 (4Y)
/X19: P1.19, U19.3 (1Y)
/X20: P1.20, U19.14 (4Y)
/X21: P1.21, U24.3 (1Y)
/X22: P1.22, U24.14 (4Y)
/X23: P1.23, U26.3 (1Y)
/X24: P1.24, U26.14 (4Y)
/X_S_Clock: U1.11 (SRCLK), U7.11 (SRCLK), U13.11 (SRCLK); also elsewhere on the board
/X_S_Data: U1.14 (SER); also elsewhere on the board
/X_S_Latch: U1.12 (RCLK), U7.12 (RCLK), U13.12 (RCLK); also elsewhere on the board
/Y_S_Clock: U2.11 (SRCLK), U8.11 (SRCLK); also elsewhere on the board
/Y_S_Data: U2.14 (SER); also elsewhere on the board
/Y_S_Latch: U2.12 (RCLK), U8.12 (RCLK); also elsewhere on the board
GND: C1.2, C2.2, J1.2, J1.3, R2.2, R3.1, R4.1, R5.1, U1.8 (GND), U2.8 (GND), U3.4 (GND), U3.5 (GND), U3.12 (GND), U3.13 (GND), U4.4 (GND), U4.5 (GND), U4.12 (GND), U4.13 (GND), U5.4 (GND), U5.5 (GND), U5.12 (GND), U5.13 (GND), U6.4 (GND), U6.5 (GND), U6.12 (GND), U6.13 (GND), U7.8 (GND), U8.8 (GND), U9.4 (GND), U9.5 (GND), U9.12 (GND), U9.13 (GND), U10.4 (GND), U10.5 (GND), U10.12 (GND), U10.13 (GND), U11.4 (GND), U11.5 (GND), U11.12 (GND), U11.13 (GND), U12.4 (GND), U12.5 (GND), U12.12 (GND), U12.13 (GND), U13.8 (GND), U14.4 (GND), U14.5 (GND), U14.12 (GND), U14.13 (GND), U15.4 (GND), U15.5 (GND), U15.12 (GND), U15.13 (GND), U16.4 (GND), U16.5 (GND), U16.12 (GND), U16.13 (GND), U17.4 (GND), U17.5 (GND), U17.12 (GND), U17.13 (GND), U18.4 (GND), U18.5 (GND), U18.12 (GND), U18.13 (GND), U19.4 (GND), U19.5 (GND), U19.12 (GND), U19.13 (GND), U20.10 (GND), U21.4 (GND), U21.5 (GND), U21.12 (GND), U21.13 (GND), U22.4 (GND), U22.5 (GND), U22.12 (GND), U22.13 (GND), U23.4 (GND), U23.5 (GND)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; also elsewhere on the board
unnamed: D1.1 (K), R3.2
unnamed: D2.1 (K), R4.2
unnamed: D3.1 (K), R5.2
unnamed: R1.1, U20.15 (RX)
unnamed: U1.9 (~QH), U7.14 (SER)
unnamed: U2.9 (~QH), U8.14 (SER)
unnamed: U7.9 (~QH), U13.14 (SER)

Notes on the sheet:
Connector Columns (X)
Connector Rows (Y)
H-Bridges for Rows (Y)
H-Bridges for Columns (X)

Parts:
C3: 0.33uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
C4: 1uF; CP_Radial_D6.3mm_P2.50mm
C5, C8: 100nF; C_Disc_D4.7mm_W2.5mm_P5.00mm
C6, C7: 22p; C_Disc_D4.7mm_W2.5mm_P5.00mm
P4: CONN_02X03; Pin_Header_Straight_2x03_Pitch2.54mm
R6: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R7: 1M; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
SW1: SW_Push; SW_PUSH_6mm
U27: L7805; TO-220_Vertical
U28: ATMEGA328P-PU; DIP-28_W7.62mm_Socket
Y1: Crystal; Crystal_HC49-4H_Vertical

Connections:
+5V: C4.1, C5.1, P4.2, R6.1, U27.3 (OUT), U28.7 (VCC), U28.20 (AVCC); also elsewhere on the board
+12V: C3.1, U27.1 (IN); also elsewhere on the board
/DATA_X: U28.14 ((PCINT0/CLKO/ICP1)PB0); also elsewhere on the board
/DATA_Y: U28.15 ((PCINT1/OC1A)PB1); also elsewhere on the board
/Driver/ATM_RX: U28.2 ((PCINT16/RXD)PD0); also elsewhere on the board
/Driver/ATM_TX: U28.3 ((PCINT17/TXD)PD1); also elsewhere on the board
/OE: U28.16 ((PCINT2/OC1B/~SS~)PB2); also elsewhere on the board
/X_S_Clock: U28.5 ((PCINT19/OC2B/INT1)PD3); also elsewhere on the board
/X_S_Data: U28.4 ((PCINT18/INT0)PD2); also elsewhere on the board
/X_S_Latch: U28.6 ((PCINT20/XCK/T0)PD4); also elsewhere on the board
/Y_S_Clock: U28.12 ((PCINT22/OC0A/AIN0)PD6); also elsewhere on the board
/Y_S_Data: U28.11 ((PCINT21/OC0B/T1)PD5); also elsewhere on the board
/Y_S_Latch: U28.13 ((PCINT23/AIN1)PD7); also elsewhere on the board
GND: C3.2, C4.2, C5.2, C6.1, C7.1, C8.2, P4.6, SW1.2, U27.2 (GND), U28.8 (GND), U28.22 (GND); also elsewhere on the board
unnamed: C6.2, R7.1, U28.9 ((PCINT6/XTAL1/TOSC1)PB6), Y1.1
unnamed: C7.2, R7.2, U28.10 ((PCINT7/XTAL2/TOSC2)PB7), Y1.2
unnamed: C8.1, U28.21 (AREF)
unnamed: P4.1, U28.18 ((PCINT4/MISO)PB4)
unnamed: P4.3, U28.19 ((PCINT5/SCK)PB5)
unnamed: P4.4, U28.17 ((PCINT3/OC2A/MOSI)PB3)
unnamed: P4.5, R6.2, SW1.1, U28.1 ((PCINT14/~RESET~)PC6)

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
Board: 2 copper layers, 100.0 x 100.0 mm, 53 parts (0 on the bottom side), 127 nets.

File Schematics_H-Bridge/Flipdot_H-Bridge_BOM.csv:

"Id";"Designator";"Package";"Quantity";"Designation";"Supplier and ref";
1;"REF**,REF**,REF**,REF**,REF**,REF**,REF**,REF**,REF**,REF**,REF**,REF**,REF**,REF**,REF**,REF**,REF**,REF**,REF**,REF**,REF**";"VIA-0.6mm";21;"VIA-0.6mm";;;
2;"SW1";"SW_PUSH_6mm";1;"SW_Push";;;
3;"P3,P2";"Pin_Header_Straight_2x08_Pitch2.54mm";2;"CONN_02X08";;;
4;"P1";"Pin_Header_Straight_2x13_Pitch2.54mm";1;"CONN_02X13";;;
5;"Y1";"Crystal_HC49-4H_Vertical";1;"Crystal";;;
6;"C8,C5,C1";"C_Disc_D4.7mm_W2.5mm_P5.00mm";3;"100nF";;;
7;"P4";"Pin_Header_Straight_2x03_Pitch2.54mm";1;"CONN_02X03";;;
8;"C7,C6";"C_Disc_D4.7mm_W2.5mm_P5.00mm";2;"22p";;;
9;"C2";"CP_Radial_D6.3mm_P2.50mm";1;"10uF";;;
10;"D2";"LED_D3.0mm";1;"Led_Yellow";;;
11;"D3";"LED_D3.0mm";1;"Led_Red";;;
12;"D1";"LED_D3.0mm";1;"Led_Green";;;
13;"J1";"BARREL_JACK";1;"Barrel_Jack";;;
14;"C4";"CP_Radial_D6.3mm_P2.50mm";1;"1uF";;;
15;"C3";"C_Disc_D4.7mm_W2.5mm_P5.00mm";1;"0.33uF";;;
16;"U1,U2,U7,U8,U13";"DIP-16_W7.62mm_Socket";5;"74HC595";;;
17;"U3,U4,U5,U6,U9,U10,U11,U12,U14,U15,U16,U17,U18,U19,U21,U22,U23,U24,U25,U26";"DIP-16_W7.62mm_Socket";20;"L293D";;;
18;"U28";"DIP-28_W7.62mm_Socket";1;"ATMEGA328P-PU";;;
19;"U27";"TO-220_Vertical";1;"L7805";;;
20;"R1";"R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical";1;"1k";;;
21;"R2";"R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical";1;"2k";;;
22;"R3,R4,R5";"R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical";3;"1.5K";;;
23;"R6";"R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical";1;"10k";;;
24;"R7";"R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical";1;"1M";;;
25;"REF**";"MountingHole_5.3mm_M5_DIN965";1;"MountingHole_5.3mm_M5_DIN965";;;
26;"U20";"ESP8266_D1_Mini_cropped";1;"ESP8266_D1_Mini";;;
27;"G***";"FDD_Icon";1;"LOGO";;;

## Commit log

2017-09-03 moved files
2017-09-05 routing of H-bridge traces
2017-09-05 added plots of the schematic
2018-02-21 finished layout V1
2018-02-21 gernerated Gerber and drill files in plot/
2018-02-21 updated schematic plots plots
2018-04-25 updated and condensed Atmel328 firmware into one file
2018-04-25 removed old test sketch
2018-04-25 labeled triac design as depricated
2018-04-25 PCB V1
2018-04-25 removed dead files
2018-04-25 PCB v1.1, minor fixes in connector and silkscreen layout
2018-04-25 removed old ESP code
2018-04-25 PNG version of wiring
2018-04-25 cleanup
2018-04-25 removed double triac design
2018-05-22 added FDD library to interface with the display and Adafruit GFX library
2018-05-22 removed duplicated ESP folder and moved Atmel driver sketch into its own folder
2018-06-07 added example sketches
2018-08-15 updated driver to allow for MultiDisplay use
2018-08-16 updated examles
2018-08-16 updated library and sketch for the multidisplay in the common room
2018-08-29 There you go Martin
2018-09-04 Adding custom character handling and bytestream
2018-09-05 added "Passwords.h" demo file"
2018-09-06 trying another comparison method
2018-09-07 removed binary handling as it causes the ESP to crash
2018-09-07 fixed special character display
2018-09-26 added basic Binary display test
2018-09-27 initialize *empty* array
2018-10-09 removed 10PM message due to popular demand
2018-10-09 added an hourly display refresh to reset dead pixels
2018-10-13 added animation of function principle
2018-11-14 Test
2018-11-14 another test
2018-11-14 First PIO based version which compiled successfully
2018-11-14 Switched to paho mqtt. Compiles, but has to be tested.
2018-11-14 limited binary data to 144 byte
2018-12-02 setting keepalive
2018-12-02 tested new PIO implementation
2019-01-02 Added a switch for MQTT Implementations. Note: Binary topic most likely broken
2019-01-03 PubSubClient implementation compiles.
2019-01-03 First draft of the pubsubclient implementation Creates garbage when message is shorter than 5 bytes
2019-01-06 bugfixing
